# Keil uVision project wifi_web_server_demo.uvproj, settings and files
target wifi_web_server_demo_flash (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) IROM2(0x500000-0x5FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: wifi_web_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __SAM4SD32C__ USE_SAM4S_XPLAINED_PRO
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\atmel\devices\sam4s;..\..\..\..\common\atmel\devices\wilc1000;..\..\..\..\common\atmel\boards\common;..\..\..\..\common\atmel\boards\sam4s_xplained_pro;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\sam4s_flash.sct
  group Demo Sources
    ./: startup_sam4s.s retarget.c
    ../src/: system_sam4s.c main.c debug.c wilc1000_callbacks.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h wilc1000_config.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/: wilc1000_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_server.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/: wilc1000_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h ndp_router_adv.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_server.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group WILC1000 BSP Sources
    ../../../../common/atmel/devices/wilc1000/bsp/source/: nm_bsp_sam4s.c
    ../../../../common/atmel/devices/wilc1000/bus_wrapper/source/: nm_bus_wrapper_sam4s.c
  group WILC1000 BSP Headers
    ../../../../common/atmel/devices/wilc1000/bsp/include/: nm_bsp.h nm_bsp_sam4s.h
    ../../../../common/atmel/devices/wilc1000/bus_wrapper/include/: nm_bus_wrapper.h
  group WILC1000 Driver Sources
    ../../../../common/atmel/devices/wilc1000/common/source/: nm_common.c
    ../../../../common/atmel/devices/wilc1000/driver/source/: m2m_hif.c m2m_periph.c m2m_wifi.c nmasic.c nmbus.c nmdrv.c nmspi.c spi_flash.c
    ../../../../common/atmel/devices/wilc1000/drv_hash/: PMK.c
  group WILC1000 Driver Headers
    ../../../../common/atmel/devices/wilc1000/common/include/: nm_common.h
    ../../../../common/atmel/devices/wilc1000/driver/include/: m2m_periph.h m2m_types.h m2m_wifi.h wifi_firmware_1000b.h
    ../../../../common/atmel/devices/wilc1000/driver/source/: m2m_hif.h nmasic.h nmbus.h nmdrv.h nmspi.h
    ../../../../common/atmel/devices/wilc1000/drv_hash/: crypto.h
  group WILC1000 OS Support Source
    ../../../../common/atmel/devices/wilc1000/os/source/: m2m_wifi_ex.c
  group WILC1000 OS Support Headers
    ../../../../common/atmel/devices/wilc1000/os/include/: m2m_wifi_ex.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/rvds/arm_cm3/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/rvds/arm_cm3/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group SAM4S-Xplained-Pro Headers
    ../../../../common/atmel/boards/sam4s_xplained_pro/: sam4s_xplained_pro.h
target wifi_web_server_demo_sram (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: as above
  output: wifi_web_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __SAM4SD32C__ USE_SAM4S_XPLAINED_PRO
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\sam4s_sram.sct

# Keil uVision project mqtt_client_demo.uvproj, settings and files
target mqtt_client_demo_flash (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: mqtt_client_demo_flash
  c flags: Optim=1
  c define: PART_TM4C1294NCPDT TARGET_IS_SNOWFLAKE_RA0 USE_EK_TM4C1294XL
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\ti\devices\tm4c129;..\..\..\..\common\ti\boards\ek_tm4c1294xl;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129_flash.sct
  group Demo Sources
    ./: startup_tm4c129.s retarget.c
    ../src/: system_tm4c129.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/: tm4c129_eth.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../../../../../cyclone_tcp/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/: tm4c129_eth.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.h mqtt_client_misc.h mqtt_client_packet.h mqtt_client_transport.h mqtt_common.h
    ../../../../../cyclone_tcp/web_socket/: web_socket.h web_socket_auth.h web_socket_frame.h web_socket_misc.h web_socket_transport.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_client_misc.c tls_server.c tls_server_misc.c tls_common.c tls_record.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_client_misc.h tls_server.h tls_server_misc.h tls_common.h tls_record.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md5.c sha1.c sha224.c sha256.c sha384.c sha512.c hmac.c rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_cbc.c cipher_mode_ccm.c cipher_mode_gcm.c chacha.c poly1305.c chacha20_poly1305.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c mpi.c asn1.c oid.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md5.h sha1.h sha224.h sha256.h sha384.h sha512.h hmac.h rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_cbc.h cipher_mode_ccm.h cipher_mode_gcm.h chacha.h poly1305.h chacha20_poly1305.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h mpi.h asn1.h oid.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group EK-TM4C1294XL Sources
    ../../../../common/ti/boards/ek_tm4c1294xl/drivers/: pinout.c
  group EK-TM4C1294XL Headers
    ../../../../common/ti/boards/ek_tm4c1294xl/drivers/: pinout.h
  group Tiva Periph Driver Lib Sources
    ../../../../common/ti/devices/tm4c129/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Tiva Periph Driver Lib Headers
    ../../../../common/ti/devices/tm4c129/driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h onewire.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
target mqtt_client_demo_sram (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: as above
  output: mqtt_client_demo_sram
  c flags: Optim=1
  c define: PART_TM4C1294NCPDT TARGET_IS_SNOWFLAKE_RA0 USE_EK_TM4C1294XL
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129_sram.sct
